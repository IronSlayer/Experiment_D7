<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>spectrum</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frequency_rx</value></param>
<param><key>value</key><value>476.0e6</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>function_1</value></param>
<param><key>block_id</key><value>probe_signal_1</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>10</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>function_2</value></param>
<param><key>block_id</key><value>avg_mag_sqrd</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>10</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>function_3</value></param>
<param><key>block_id</key><value>probe_signal_2</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>10</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>function_2</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_0</value></param>
<param><key>value</key><value>function_1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_1</value></param>
<param><key>value</key><value>function_3</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>analog_probe_avg_mag_sqrd_x</key>
<param><key>id</key><value>avg_mag_sqrd</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>threshold</key><value>0</value></param>
<param><key>type</key><value>c</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_0_0</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n</value></param>
<param><key>n</key><value>int(samp_rate / 30)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>nlog10_ff</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>6e6</value></param>
<param><key>freq0</key><value>frequency_rx</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>3</value></param>
<param><key>args</key><value>bladerf=0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>probe_signal_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>probe_signal_2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>frequency_rx</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>avg</key><value>0.10</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_VERT</value></param>
<param><key>type</key><value>float</value></param>
<param><key>color1</key><value>("blue", "red")</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>"Power"</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_VERT</value></param>
<param><key>type</key><value>float</value></param>
<param><key>color1</key><value>("blue", "red")</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>-20</value></param>
<param><key>name</key><value>"Power"</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>0.05</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>probe_signal_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_0_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n</source_block_id><sink_block_id>nlog10_ff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nlog10_ff</source_block_id><sink_block_id>probe_signal_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nlog10_ff</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source</source_block_id><sink_block_id>avg_mag_sqrd</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>blocks_keep_one_in_n</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
